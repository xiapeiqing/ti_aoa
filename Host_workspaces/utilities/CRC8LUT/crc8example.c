// http://blog.goo.ne.jp/masaki_goo_2006/e/69f286d90e6140e6e8c021e43a11c815
#include <stdio.h>
#include <stdlib.h>
#include <limits.h>     // CHAR_BIT

#define u8 unsigned char
#define u16 unsigned short

// 記号定数
// #define MSB_CRC8    (0x85)      // x8 + x7 + x2 + x0
//                           8 7654 3210
// example of the URL 8720   * 1000 0101 = 0x85
// CRC8               876420 * 1101 0101 = 0xd5
// CRC8-CCITT         87320  * 1000 1101 = 0x8d
// CRC8-SAEJ1850      ...
// CRC8-ATM           ...
// CRC8-Dallas/Maxim  8540   * 0011 0001 = 0x31 <- This is for SHT2x
#define MSB_CRC8  (0x31)

static unsigned char CRC8Table[ 256 ] = {
  0x00, 0x31, 0x62, 0x53, 0xC4, 0xF5, 0xA6, 0x97,
	0xB9, 0x88, 0xDB, 0xEA, 0x7D, 0x4C, 0x1F, 0x2E,
	0x43, 0x72, 0x21, 0x10, 0x87, 0xB6, 0xE5, 0xD4,
	0xFA, 0xCB, 0x98, 0xA9, 0x3E, 0x0F, 0x5C, 0x6D,
	0x86, 0xB7, 0xE4, 0xD5, 0x42, 0x73, 0x20, 0x11,
	0x3F, 0x0E, 0x5D, 0x6C, 0xFB, 0xCA, 0x99, 0xA8,
	0xC5, 0xF4, 0xA7, 0x96, 0x01, 0x30, 0x63, 0x52,
	0x7C, 0x4D, 0x1E, 0x2F, 0xB8, 0x89, 0xDA, 0xEB,
	
	0x3D, 0x0C, 0x5F, 0x6E, 0xF9, 0xC8, 0x9B, 0xAA,
	0x84, 0xB5, 0xE6, 0xD7, 0x40, 0x71, 0x22, 0x13,
	0x7E, 0x4F, 0x1C, 0x2D, 0xBA, 0x8B, 0xD8, 0xE9,
	0xC7, 0xF6, 0xA5, 0x94, 0x03, 0x32, 0x61, 0x50,
	0xBB, 0x8A, 0xD9, 0xE8, 0x7F, 0x4E, 0x1D, 0x2C,
	0x02, 0x33, 0x60, 0x51, 0xC6, 0xF7, 0xA4, 0x95,
	0xF8, 0xC9, 0x9A, 0xAB, 0x3C, 0x0D, 0x5E, 0x6F,
	0x41, 0x70, 0x23, 0x12, 0x85, 0xB4, 0xE7, 0xD6,
	
	0x7A, 0x4B, 0x18, 0x29, 0xBE, 0x8F, 0xDC, 0xED,
	0xC3, 0xF2, 0xA1, 0x90, 0x07, 0x36, 0x65, 0x54,
	0x39, 0x08, 0x5B, 0x6A, 0xFD, 0xCC, 0x9F, 0xAE,
	0x80, 0xB1, 0xE2, 0xD3, 0x44, 0x75, 0x26, 0x17,
	0xFC, 0xCD, 0x9E, 0xAF, 0x38, 0x09, 0x5A, 0x6B,
	0x45, 0x74, 0x27, 0x16, 0x81, 0xB0, 0xE3, 0xD2,
	0xBF, 0x8E, 0xDD, 0xEC, 0x7B, 0x4A, 0x19, 0x28,
	0x06, 0x37, 0x64, 0x55, 0xC2, 0xF3, 0xA0, 0x91,
	
	0x47, 0x76, 0x25, 0x14, 0x83, 0xB2, 0xE1, 0xD0,
	0xFE, 0xCF, 0x9C, 0xAD, 0x3A, 0x0B, 0x58, 0x69,
	0x04, 0x35, 0x66, 0x57, 0xC0, 0xF1, 0xA2, 0x93,
	0xBD, 0x8C, 0xDF, 0xEE, 0x79, 0x48, 0x1B, 0x2A,
	0xC1, 0xF0, 0xA3, 0x92, 0x05, 0x34, 0x67, 0x56,
	0x78, 0x49, 0x1A, 0x2B, 0xBC, 0x8D, 0xDE, 0xEF,
	0x82, 0xB3, 0xE0, 0xD1, 0x46, 0x77, 0x24, 0x15,
	0x3B, 0x0A, 0x59, 0x68, 0xFF, 0xCE, 0x9D, 0xAC,
};

// CRC8の計算(生成多項式:0x85,左送り)
static unsigned char crc8_1( const void *buff, size_t size )
{
    unsigned char *p = (unsigned char *)buff;
    unsigned char crc8;
    int i;
    
    for ( crc8 = 0x00 ; size != 0 ; size-- ){
        crc8 ^= *p++;
        
        for (i = 0 ; i < CHAR_BIT ; i++ ){
            if ( crc8 & 0x80 ){
                crc8 <<= 1; crc8 ^= MSB_CRC8;
            }
            else{
                crc8 <<= 1;
            }
        }
    }
    return crc8;
}

u8
crc8_2(u8 *d, int n)
{
  int i;
  u8 bit, crc;

  for (i = 0; i < n; i++) {
    crc ^= d[i];
    for (bit = 8; bit > 0; bit--) {
      if (crc & 0x80)
        crc = (crc<<1)^0x131;
      else
        crc = (crc<<1);
    }
  }
  return crc;
}

// CRC8テーブルから計算
static unsigned char crc8_3( const void *buff, size_t size )
{
    unsigned char *data = (unsigned char *)buff;
    unsigned char  crc8 = 0x00;
    
    while ( size != 0 ){
        crc8 = CRC8Table[ crc8 ^ *data ];
        data++;
        size--;
    }
    return crc8;
}

int main()
{
#define length 4
  u8 buf[length];
  u8 c1, c2, c3;
  for (int i = 0; i<length; i++)
    buf[i] = i+49; 
  // "1234"
  c1 = crc8_1(buf, length);
  c2 = crc8_2(buf, length);
  c3 = crc8_3(buf, length);
  printf(", %02x, %02x, %02x", c1, c2, c3);
  printf("algo1 and 3 agree with matlab & python result, not the 2nd algo\n");
  
}
/*
int
main()
{
  char *d, *t, text[1024], t2[3] = "  ";
  u8 *b, buf[1024];
  u8 c1, c2, c3;
  int i;

  while (fgets(text, 1024, stdin) != NULL) {
    for (t = text, b = buf; *t != '\n'; b++) {
      t2[0] = *t++;
      if (*t == '\n')
        break;
      t2[1] = *t++;
      *b = strtoul(t2, &d, 16);
    }
    for (i = 0; i < b - buf; i++)
      printf("%02x", buf[i]);
    c1 = crc8_1(buf, b - buf);
    c2 = crc8_2(buf, b - buf);
    c3 = crc8_3(buf, b - buf);
    printf(", %02x, %02x, %02x", c1, c2, c3);
    printf("\n");
  }
}*/
